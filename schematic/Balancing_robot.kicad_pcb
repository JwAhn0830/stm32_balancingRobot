# Repository JwAhn0830/stm32_balancingRobot

File README.md:

# stm32_balancingRobot

## Goal
- Get used to stm32 mcu and STM32CubeIDE
- Get some HW design experience
   - 4 layer PCB
   - CAD

## brief

balacing robot with HAL library

## Project Diagram

## Dev Enviroment
- Hardware
  - KiCAD
  - Solidworks
- Software
  - STM32CubeIDE (stm32)
  - ESP-IDF (esp32)
  - nodeJs

## Feature
- PID control
- Complementary Filter
- HTTP protocol (post)
- socket
- [mpu6050](https://github.com/JwAhn0830/mpu6050)

## Prototype Demo
Added PID Controller to tune each of PID gain (Kp, Ki, Kd)

https://github.com/user-attachments/assets/21620eae-1ff0-435f-92ad-7fb4adb67d83

[schematic](https://github.com/JwAhn0830/stm32_balancingRobot/tree/main/schematic)  
[3d model](https://github.com/JwAhn0830/stm32_balancingRobot/tree/main/3Dmodel)  
[server](https://github.com/JwAhn0830/stm32_balancingRobot/tree/main/server)

## KiCad design schematic/Balancing_robot.kicad_pcb

File schematic/README.md:

# Schematic
## 1. main

## 2. Power

## 3. CPU_Block

# Prototype PCB
  <br>

Parts:
BZ2: Buzzer; Buzzer_D14mm_H7mm_P10mm
C2, C21: 100nF 50V; C_0603_1608Metric
C3: 100nF/2V; C_0603_1608Metric
C4: 2.2nF/50V; C_0603_1608Metric
C5: 100nF/4V; C_0603_1608Metric
D1: MotorPw[RED]; LED_0805_2012Metric
D2: GyroPw[RED]; LED_0805_2012Metric
D3: WiFiPw[BLUE]; LED_0805_2012Metric
D8: DEBUG[GREEN]; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x03_Pin; SS-12D00
J14: UART2; PinHeader_1x04_P2.54mm_Horizontal
M1: Motor1; PinHeader_1x02_P2.54mm_Horizontal
M2: Motor2; PinHeader_1x02_P2.54mm_Horizontal
R1: 1.5K; R_0603_1608Metric
R2: 1K; R_0603_1608Metric
R3: 240; R_0603_1608Metric
R4, R6, R7, R18: 4.7K; R_0603_1608Metric
R5: 180; R_0603_1608Metric
R8: 33; R_0603_1608Metric
R13: 10K; R_0603_1608Metric
R17: 100; R_0603_1608Metric
SW2: DEBUG[BLUE]; SW_PUSH_6mm_H9.5mm
U1: STM32F103RBT6; PARTREV 18
U2: MPU6050; QFN50P400X400X95-24N
U3: ESP32; Lolin D32
U8: L293DD; SOIC127P1032X265-20N; PARTREV N/A

Connections:
3.3V: C2.2, C5.1, D3.2 (A), J14.4, R5.2, R6.1, R7.1, R13.1, U1.1 (VBAT), U1.19 (VDD_4), U1.32 (VDD_1), U1.48 (VDD_2), U1.64 (VDD_3), U2.8 (VLOGIC), U2.13 (VCC), U3.3V; also elsewhere on the board
5V(BAT): J1.1, J1.2; also elsewhere on the board
7.4V: R1.1, U8.10 (VS); also elsewhere on the board
/ADC2: R1.2, R2.1, U1.15 (PA1)
/ENA: U1.22 (PA6), U8.1 (ENABLE_1)
/ENB: U1.23 (PA7), U8.11 (ENABLE_2)
/IN1: U1.37 (PC6), U8.2 (INPUT_1)
/IN2: U1.38 (PC7), U8.9 (INPUT_2)
/IN3: U1.39 (PC8), U8.12 (INPUT_3)
/IN4: U1.40 (PC9), U8.19 (INPUT_4)
/INT: U2.12 (INT)
/OUT1: M1.2 (-), U8.3 (OUTPUT_1)
/OUT2: M1.1 (+), U8.8 (OUTPUT_2)
/OUT3: M2.2 (-), U8.13 (OUTPUT_3)
/OUT4: M2.1 (+), U8.18 (OUTPUT_4)
/SCL_N: R7.2, U1.61 (PB8), U2.23 (SCL)
/SDA_P: R6.2, U1.62 (PB9), U2.24 (SDA)
/UART2_RX: J14.2, U1.17 (PA3)
/UART2_TX: J14.3, U1.16 (PA2)
/UART3_RX: U1.29 (PB10), U3.17
/UART3_TX: U1.30 (PB11), U3.16
AGND: U1.12 (VSSA); also elsewhere on the board
BOOT0: U1.60 (BOOT0); also elsewhere on the board
BOOT1: U1.28 (PB2); also elsewhere on the board
BUZZER: BZ2.1 (+), U1.58 (PB6)
GND: BZ2.2 (-), C2.1, C3.2, C4.2, C5.2, D1.1 (K), D2.1 (K), D8.1 (K), J14.1, R2.2, R4.2, R18.1, SW2.1, U1.18 (VSS_4), U1.31 (VSS_1), U1.47 (VSS_2), U1.63 (VSS_3), U2.1 (CLKIN), U2.11 (FSYNC), U2.18 (GND), U3.GND, U8.4 (GND), U8.5 (GND), U8.6 (GND), U8.7 (GND), U8.14 (GND), U8.15 (GND), U8.16 (GND), U8.17 (GND); also elsewhere on the board
unnamed: C21.2, R18.2
unnamed: D1.2 (A), R3.2
unnamed: D2.2 (A), R5.1
unnamed: D3.1 (K), R8.1
unnamed: D8.2 (A), R17.1
unnamed: J1.3, R3.1, U8.20 (VSS)
unnamed: R8.2, U3.25
unnamed: R4.1, U2.9 (AD0)
unnamed: C4.1, U2.20 (CPOUT)
unnamed: C3.1, U2.10 (REGOUT)
OSC_IN: U1.5 (PD0_OSC_IN); also elsewhere on the board
OSC_OUT: U1.6 (PD1_OSC_OUT); also elsewhere on the board
PA0: U1.14 (PA0-WKUP)
PA4: U1.20 (PA4)
PA5: R17.2, U1.21 (PA5)
PA9: U1.42 (PA9)
PA10: U1.43 (PA10)
PA15: U1.50 (PA15)
PB4: U1.56 (PB4)
PB5: U1.57 (PB5)
PB12: U1.33 (PB12)
PB13: U1.34 (PB13)
PB14: U1.35 (PB14)
PB15: U1.36 (PB15)
PC0: U1.8 (PC0)
PC1: U1.9 (PC1)
PC2: U1.10 (PC2)
PC3: U1.11 (PC3)
PC4: U1.24 (PC4)
PC5: U1.25 (PC5)
PC12: U1.53 (PC12)
PC13: C21.1, R13.2, SW2.2, U1.2 (PC13-TAMPER-RTC)
PD2: U1.54 (PD2)
RESET: U1.7 (~RST); also elsewhere on the board
SWCLK: U1.49 (PA14); also elsewhere on the board
SWDIO: U1.46 (PA13); also elsewhere on the board
TRACESWO: U1.55 (PB3); also elsewhere on the board
USB_D+: U1.45 (PA12); also elsewhere on the board
USB_D-: U1.44 (PA11); also elsewhere on the board
VDDA: U1.13 (VDDA); also elsewhere on the board

Notes on the sheet:
Ratio of R1 and R2 must be 1.5 : 1
TIM3_CH1
PC11
User
All 64 ohm resister replaced to 68 ohm
TIM3_CH2
TIM4_CH1
PC10

Parts:
C6, C7, C8, C9, C10, C14: 100nF; C_0603_1608Metric
C11, C13, C15: 1uF; C_0603_1608Metric
C12: 10uF; C_0603_1608Metric
C19: 0.33uF; C_0603_1608Metric
C20: 100nF 50V; C_0603_1608Metric
D6: MCUPw[RED]; LED_0805_2012Metric
FB1: FerriteBead; L_0603_1608Metric
J4: 10118194-0001LF; AMPHENOL_10118194-0001LF; PARTREV D
J5: PW_Conn; Molex_SPOX_5267-02A_1x02_P2.50mm_Vertical
J6: PwSelectPin; PinHeader_1x03_P2.54mm_Vertical
J7: Power_conn; SS-12D00
R9: 1.5k; R_0603_1608Metric
R10, R11: 22; R_0603_1608Metric
R14: 180; R_0603_1608Metric
U4: LD39050PU33R; SON95P300X300X100-7N; DIGI-KEY_PART_NUMBER 497-8716-1-ND
U5: L7805CDT-TR; VREG_L7805CDT-TR; PARTREV 36

Connections:
3.3V: C6.1, C7.1, C8.1, C10.1, C12.1, C15.1, FB1.2, R9.1, R14.1, U4.4 (VOUT); also elsewhere on the board
5V(BAT): C20.1, J6.1, U5.2 (OUTPUT); also elsewhere on the board
7.4V: C19.1, J5.2, U5.1 (INPUT); also elsewhere on the board
AGND: C9.2, C11.2; also elsewhere on the board
GND: C6.2, C7.2, C8.2, C10.2, C12.2, C13.2, C14.2, C15.2, C19.2, C20.2, D6.1 (K), J4.5 (GND), J4.SH1 (SHIELD), J4.SH2 (SHIELD), J4.SH3 (SHIELD), J4.SH4 (SHIELD), J4.SH5 (SHIELD), J4.SH6 (SHIELD), J5.1, U4.2 (GND), U4.7 (GND), U5.3 (GROUND); also elsewhere on the board
unnamed: D6.2 (A), R14.2
unnamed: J4.3 (D+), R11.1
unnamed: J4.2 (D-), R10.1
unnamed: J6.2, J7.3
unnamed: C13.1, C14.1, J7.1, J7.2, U4.1 (EN), U4.6 (VIN)
U5V: J4.1 (VCC), J6.3
USB_D+: R9.2, R11.2; also elsewhere on the board
USB_D-: R10.2; also elsewhere on the board
VDDA: C9.1, C11.1, FB1.1; also elsewhere on the board

Notes on the sheet:
replaced to 330nF
min. 4.7uF, type. 10uF(tantal cap)
출력 전력 핀
3x3 mm
100nF/50V

Parts:
C16, C17: 30pF; C_0603_1608Metric
C18: 100nF 50V; C_0603_1608Metric
J8: Boot1_Conn; PinHeader_1x03_P2.54mm_Vertical
J9: Boot0_Conn; PinHeader_1x03_P2.54mm_Vertical
J10: SWD; PinHeader_1x06_P2.54mm_Horizontal
R15, R16: 10K; R_0603_1608Metric
SW3: RESET; SW_PUSH_6mm_H9.5mm
Y1: Crystal 8Mh/18pF; Crystal_HC49-U_Vertical

Connections:
3.3V: J8.1, J9.1, J10.4; also elsewhere on the board
BOOT0: R16.2; also elsewhere on the board
BOOT1: R15.2; also elsewhere on the board
GND: C16.1, C17.1, C18.2, J8.3, J9.3, J10.1, SW3.1; also elsewhere on the board
unnamed: J8.2, R15.1
unnamed: J9.2, R16.1
OSC_IN: C17.2, Y1.1; also elsewhere on the board
OSC_OUT: C16.2, Y1.2; also elsewhere on the board
RESET: C18.1, J10.5, SW3.2; also elsewhere on the board
SWCLK: J10.2; also elsewhere on the board
SWDIO: J10.3; also elsewhere on the board
TRACESWO: J10.6; also elsewhere on the board

Notes on the sheet:
1,2 connected : main flash memory (default) 2,3 connected : system memory
1,2 connected : program the device via usb 2,3 connected : run the program (default)

Board: 4 copper layers, 100.0 x 50.0 mm, 68 parts (8 on the bottom side), 54 nets.

## Code that names these connections

File F103_boardTest/F103_boardTest.ioc (part):

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Mcu.Name=STM32F103R(8-B)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F103RBTx
PA1.Signal=ADCx_IN1
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA5.Signal=GPIO_Output
PA6.Signal=S_TIM3_CH1
PA7.Signal=S_TIM3_CH2
PB10.Mode=Asynchronous
PB10.Signal=USART3_TX
PB11.Mode=Asynchronous
PB11.Signal=USART3_RX
PB6.Signal=S_TIM4_CH1
PB8.Mode=I2C
PB8.Signal=I2C1_SCL
PB9.Mode=I2C
PB9.Signal=I2C1_SDA
PC13-TAMPER-RTC.Signal=GPIO_Input
PC6.Signal=GPIO_Output
PC7.Signal=GPIO_Output
PC8.Signal=GPIO_Output
PC9.Signal=GPIO_Output
PD0-OSC_IN.Mode=HSE-External-Oscillator
PD0-OSC_IN.Signal=RCC_OSC_IN
PD1-OSC_OUT.Mode=HSE-External-Oscillator
PD1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.SYSCLKFreq_VALUE=72000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2024-12-25 Update README.md
    added schematic
2024-12-25 Added Schematic
2025-01-08 Added 3Dmodels
2025-01-08 Added Readme
2025-01-14 Update README(schematic)
2025-01-18 Update main file
2025-01-20 Upadate ESP32 file
2025-01-20 Update server file
